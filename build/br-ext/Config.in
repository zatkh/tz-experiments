## build/br-ext/Config.in
```kconfig
source "$BR2_EXTERNAL_OPTEE_PATH/package/optee_client/Config.in"
source "$BR2_EXTERNAL_OPTEE_PATH/package/optee_examples/Config.in"
```
